options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: fmDoubleStation
    output_language: python
    title: FM Double Station
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '65'
  states: {}
- name: fd
  id: variable
  parameters:
    value: '75000'
  states: {}
- name: fm_bw
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: freq_station1
  id: variable_qtgui_range
  parameters:
    start: '88100000'
    step: fm_bw
    stop: '108100000'
    value: '98100000'
    widget: eng_slider
  states: {}
- name: freq_station2_offset
  id: variable_qtgui_range
  parameters:
    start: '-station2_range'
    step: fm_bw
    stop: station2_range
    value: '800000'
    widget: eng_slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: audio_rate*dec
  states: {}
- name: station2_range
  id: variable
  parameters:
    value: '1400000'
  states: {}
- name: taps_fm
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '100000'
    gain: '1.0'
    samp_rate: samp_rate
    width: '25000'
    win: window.WIN_HAMMING
  states: {}
- name: vol_max
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: vol_station1
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
    widget: dial
  states: {}
- name: vol_station2
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
    widget: dial
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '14000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: fd
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: analog_fm_demod_cf_0_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '14000'
    audio_stop: '20000'
    chan_rate: samp_rate
    deviation: fd
    gain: '1.0'
    tau: '75e-6'
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    num_inputs: '2'
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\C25Dante.Cometto\OneDrive - afacademy.af.edu\Documents\1 Important\3 School 2024F\2 ECE 447\dataDoubleFM_2.benjamin
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\C25Dante.Cometto\OneDrive - afacademy.af.edu\Documents\1 Important\3 School 2024F\2 ECE 447\dataDoubleFM.benjamin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_head_0_0
  id: blocks_head
  parameters:
    num_items: 30*samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_station1*vol_max
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: vol_station2*vol_max
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\C25Dante.Cometto\OneDrive - afacademy.af.edu\Documents\1 Important\3 School 2024F\2 ECE 447\doubleFMSoundStereo_2.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: audio_rate
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '0'
    decim: '1'
    samp_rate: samp_rate
    taps: taps_fm
    type: ccf
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq_station2_offset
    decim: '1'
    samp_rate: samp_rate
    taps: taps_fm
    type: ccf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Station 1 Demod"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Station 2 Demod"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Input"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Station 1 Predemod"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    name: '"Station 2 Predemod"'
    type: complex
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: dec
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: dec
    interp: '1'
    type: fff
  states: {}
- name: soapy_rtlsdr_source_0_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq_station1
    gain: '60'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_fm_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_fm_demod_cf_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_fm_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [blocks_file_source_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_head_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_1_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', rational_resampler_xxx_1, '0']
- [blocks_null_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_null_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_fm_demod_cf_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0_1_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_fm_demod_cf_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_freq_sink_x_0_1_0_0_0, '0']
- [rational_resampler_xxx_1, '0', audio_sink_1, '1']
- [rational_resampler_xxx_1, '0', blocks_wavfile_sink_0_0, '1']
- [rational_resampler_xxx_1_0, '0', audio_sink_1, '0']
- [rational_resampler_xxx_1_0, '0', blocks_wavfile_sink_0_0, '0']
- [soapy_rtlsdr_source_0_0, '0', blocks_head_0_0, '0']
- [soapy_rtlsdr_source_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [soapy_rtlsdr_source_0_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [soapy_rtlsdr_source_0_0, '0', qtgui_freq_sink_x_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
